# Keil uVision project SimPad_Nano_Anniversary_Edition.uvproj, settings and files
target SimPad Nano Anniversary Edition (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_Nano_Anniversary_Edition +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;.\SimPad Nano AE
  group SimPad Nano Anniversary Edition
    ./SimPad Nano AE/: PinMap.h
  group Public
    ./Public/IIC/: I2C.C
    ./Public/SPI/: SPI_M.C

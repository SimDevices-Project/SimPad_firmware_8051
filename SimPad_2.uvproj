# Keil uVision project SimPad_2.uvproj, settings and files
target SimPad 2 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_ch552 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SimPad 2
    ./SimPad 2/: PinMap.h
  group _SimPad 2 ES
    _SimPad 2 ES/: PinMap.h
target _SimPad 2 ES (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_ch552
  c flags: Optimize=8 SizeSpeed=1

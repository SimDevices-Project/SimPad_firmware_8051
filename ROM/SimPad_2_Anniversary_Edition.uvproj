# Keil uVision project SimPad_2_Anniversary_Edition.uvproj, settings and files
target SimPad 2 Anniversary Edition (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_2_Anniversary_Edition +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;.\SimPad 2 AE
  group SimPad 2 Anniversary Edition
    ./SimPad 2 AE/: PinMap.h

# Keil uVision project SimPad_Nano.uvproj, settings and files
target SimPad Nano (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_Nano
  c flags: Optimize=8 SizeSpeed=1
  c include: .;.\SimPad Nano
  group SimPad Nano
    ./SimPad Nano/: PinMap.h
  group _SimPad Nano ES
    _SimPad Nano ES/: PinMap.h
target _SimPad Nano ES (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad_Nano +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;.\_SimPad Nano ES

<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\SimPad_2.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\SimPad_2_Anniversary_Edition.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\SimPad_Nano.uvproj</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\SimPad_Nano_Anniversary_Edition.uvproj</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\SimPad_3.uvproj</PathAndName>
  </project>

</ProjectWorkspace>

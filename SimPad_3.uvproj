# Keil uVision project SimPad_3.uvproj, settings and files
target SimPad 3 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: SimPad_3
  c flags: Optimize=8 SizeSpeed=1
